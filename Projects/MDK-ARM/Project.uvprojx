# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.20
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F002Bx5
  c include: ..\..\Inc;..\..\Drivers\BSP\PY32F002Bxx_Start_Kit;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\PY32F0xx\Include;..\..\Drivers\PY32F002B_HAL_Driver\Inc;..\..\Drivers\FreeModbus\include;..\..\Drivers\FreeModbus\port;..\..\Drivers\FreeModbus\rtu;..\..\Drivers\FreeRTOS\Source\include;..\..\Drivers\FreeRTOS\Source\CMSIS_RTOS;..\..\Drivers\FreeRTOS\Source\portable\RVDS\ARM_CM0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ./: startup_py32f002bxx.s
  group Application/User
    ../../Src/: main.c JH1101.c gpio.c py32f002b_it.c tim.c adc.c uart.c py32f002b_hal_msp.c system_py32f002b.c CmdHelper.c product.c saf8100.c
    ../../Drivers/FreeModbus/: Modbus.c
  group Drivers/PY32F002B_HAL_Driver
    ../../Drivers/PY32F002B_HAL_Driver/Src/: py32f002b_hal.c py32f002b_hal_adc.c py32f002b_hal_comp.c py32f002b_hal_cortex.c py32f002b_hal_crc.c py32f002b_hal_exti.c py32f002b_hal_flash.c py32f002b_hal_gpio.c py32f002b_hal_i2c.c py32f002b_hal_iwdg.c py32f002b_hal_lptim.c py32f002b_hal_pwr.c py32f002b_hal_rcc.c py32f002b_hal_rcc_ex.c py32f002b_hal_spi.c py32f002b_hal_tim.c py32f002b_hal_tim_ex.c py32f002b_hal_uart.c py32f002b_hal_usart.c py32f002b_ll_adc.c py32f002b_ll_comp.c py32f002b_ll_crc.c py32f002b_ll_exti.c py32f002b_ll_gpio.c py32f002b_ll_i2c.c py32f002b_ll_lptim.c py32f002b_ll_pwr.c py32f002b_ll_rcc.c py32f002b_ll_spi.c py32f002b_ll_tim.c py32f002b_ll_usart.c py32f002b_ll_utils.c
  group FreeModbus
    ../../Drivers/FreeModbus/functions/: mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../Drivers/FreeModbus/rtu/: mbcrc.c mbrtu.c
    ../../Drivers/FreeModbus/: mb.c
  group FreeModbus/port
    ../../Drivers/FreeModbus/port/: porttimer.c portserial.c portevent.c
  group Doc
    ./: readme.txt
software components: CMSIS:CORE 5.6.0
